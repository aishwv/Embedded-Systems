<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Task 1a.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Task 2a\Task 2a.ewp</path>
    </project>
    <batchBuild />
</workspace>
