<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Task 1b.ewp</path>
    </project>
    <batchBuild />
</workspace>
